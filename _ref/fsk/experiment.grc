options:
  parameters:
    author: user
    generate_options: qt_gui
    id: experiment-fsk
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: interpolation
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: samp_sym_rate
  id: variable
  parameters:
    value: '2'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: pulse
    samp_rate: samp_rate
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/user/Downloads/_out.bin
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/user/Downloads/_framed.bin
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '1'
    type: byte
  states: {}
- name: digital_gmsk_demod_0
  id: digital_gmsk_demod
  parameters:
    comment: |-
      default 0.005 omega ?
      default 0.175 gain mu?
    freq_error: '0.0'
    gain_mu: 0.175/8
    mu: '0.5'
    omega_relative_limit: 0.005/8
    samples_per_symbol: '2'
  states: {}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: '2'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    showrf: 'True'
    type: complex
  states: {}

connections:
- [blocks_complex_to_float_0, '0', audio_sink_0, '0']
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_file_sink_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_gmsk_mod_0, '0']
- [digital_gmsk_demod_0, '0', blocks_pack_k_bits_bb_0, '0']
- [digital_gmsk_mod_0, '0', blocks_complex_to_float_0, '0']
- [digital_gmsk_mod_0, '0', digital_gmsk_demod_0, '0']
- [digital_gmsk_mod_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
