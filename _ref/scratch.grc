options:
  parameters:
    author: user
    generate_options: qt_gui
    id: scratch
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '9'
    type: byte
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_tag_gate_0_0_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_tag_gate_0_2
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: samp_sym_rate
    sensitivity: 0.75*interpolation
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: samp_sym_rate
    sensitivity: 0.75*interpolation
  states: {}

connections:
- [blocks_pack_k_bits_bb_0, '0', blocks_tag_gate_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', digital_gfsk_mod_0, '0']
- [blocks_tag_gate_0_0_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [blocks_tag_gate_0_2, '0', digital_gfsk_demod_0, '0']
- [digital_gfsk_demod_0, '0', blocks_pack_k_bits_bb_0, '0']
- [digital_gfsk_mod_0, '0', blocks_tag_gate_0_2, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
