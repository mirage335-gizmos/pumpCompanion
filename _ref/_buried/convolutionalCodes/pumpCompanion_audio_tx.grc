options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: pumpCompanion_audio_tx
    output_language: python
  states: {}

blocks:
- name: H
  id: variable_ldpc_H_matrix_def
  parameters:
    comment: Packet length must match   n bytes .
    filename: /usr/share/gnuradio/fec/ldpc/n_0500_k_0127_gap_21.alist
    gap: '21'
  states: {}
- name: access_key
  id: variable
  parameters:
    comment: |-
      Default:
      '1110 0001 0101 1010 1110 1000 1001 0011'
      '11100001010110101110100010010011'
      Alt:
      '1111 1111 1111 1111 1111 0000 0000 0011'
      '11111111111111111111000000000011'
      Unusual:   1 0000 1   1 1111 1   0011 11
    value: '''11100001010110101110100010010011'''
  states: {}
- name: arity
  id: variable
  parameters:
    value: modulus
  states: {}
- name: bitrate
  id: variable
  parameters:
    comment: |-
      Get a fiber optic SPDIF ADC if
      sound card input can only
      receive ~72kbit/s .
    value: samp_rate/sps*(1.442695041 * math.log(modulus))
  states: {}
- name: constel
  id: variable
  parameters:
    value: digital.qam_constellation(constellation_points=points, differential=True, mod_code='gray').base()
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.275'
  states: {state: disabled}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {state: disabled}
- name: excess_bw
  id: variable
  parameters:
    value: '0.275'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: interpolation
  id: variable
  parameters:
    value: '1'
  states: {state: disabled}
- name: interpolation
  id: variable
  parameters:
    value: '1'
  states: {state: disabled}
- name: interpolation
  id: variable
  parameters:
    value: '1'
  states: {}
- name: ldpc_dec_H
  id: variable_ldpc_bit_flip_decoder_def
  parameters:
    comment: |-
      Seems more effective than other FEC
      provided with GNURadio.
      Yet, still seems not very effective for FEC.
      Discouraged.
    dim1: '1'
    matrix_object: H
    max_iterations: '100'
    ndim: '1'
  states: {}
- name: ldpc_enc_H
  id: variable_ldpc_encoder_H_def
  parameters:
    H: H
    dim1: '1'
    ndim: '1'
  states: {}
- name: modulus
  id: variable
  parameters:
    value: pow(2,constel.bits_per_symbol())
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: int(32*(modulus/16))
  states: {}
- name: packet_size
  id: variable
  parameters:
    comment: |-
      CAUTION: Do NOT
      exceed 140 bytes!
      (or >>1/3 of pattern
      after footer)
    value: '1000'
  states: {}
- name: points
  id: variable
  parameters:
    value: '256'
  states: {}
- name: points
  id: variable
  parameters:
    value: '4'
  states: {state: disabled}
- name: points
  id: variable
  parameters:
    value: '64'
  states: {state: disabled}
- name: points
  id: variable
  parameters:
    value: '64'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: shift_factor
  id: variable
  parameters:
    value: ((325/samp_rate)*4)+(0.5)+(excess_bw*0.5)
  states: {}
- name: sps
  id: variable
  parameters:
    comment: samp_sym_rate
    value: '3'
  states: {state: disabled}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {state: disabled}
- name: sps
  id: variable
  parameters:
    value: '3'
  states: {}
- name: variable_cc_decoder_def_0
  id: variable_cc_decoder_def
  parameters:
    framebits: '2048'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: '[79,109]'
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {}
- name: variable_cc_encoder_def_0
  id: variable_cc_encoder_def
  parameters:
    framebits: '2048'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: '[79,109]'
    rate: '2'
    state_start: '0'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    comment: 'ATTENTION: Rate'
    gain: '1.05'
    max_gain: '65536'
    rate: (((1/(modulus+96))/sps/interpolation+(((samp_rate/48000)*0.0005))/sps/interpolation))*1.2
    reference: '1.25'
    type: complex
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: int(samp_rate*0.75)
    threshold: '-28'
    type: complex
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: |-
      ubdist/OS
      (ie. typical Linux)
    samp_rate: samp_rate
  states: {state: disabled}
- name: audio_sink_0_0_0
  id: audio_sink
  parameters:
    comment: Lenovo P1 Gen6 MSW
    device_name: Speakers (Realtek(R) Audio)
    ok_to_block: 'False'
    samp_rate: samp_rate
  states: {state: disabled}
- name: audio_sink_0_0_0_0
  id: audio_sink
  parameters:
    comment: Lenovo P1 Gen6 MSW
    device_name: Realtek HD Audio 2nd output (Realtek(R) Audio)
    ok_to_block: 'False'
    samp_rate: samp_rate
  states: {state: disabled}
- name: audio_source_0
  id: audio_source
  parameters:
    comment: |-
      ubdist/OS
      (ie. typical Linux)
    samp_rate: samp_rate
  states: {state: disabled}
- name: audio_source_0_0
  id: audio_source
  parameters:
    comment: Lenovo P1 Gen6 MSW
    device_name: '"Microphone (Realtek(R) Audio)"'
    samp_rate: samp_rate
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_2_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_2_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: os.path.join(os.environ['HOME'], 'Downloads', '_diag.rrf') if os.name == 'posix' else  os.path.join(os.environ['USERPROFILE'], 'Downloads', '_diag.rrf')
    type: byte
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: os.path.join(os.environ['HOME'], 'Downloads', '_framed.rrf') if os.name == 'posix' else  os.path.join(os.environ['USERPROFILE'], 'Downloads', '_framed.rrf')
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.35'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.1'
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_1_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_1_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_0_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_0_0_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0_0_0_1
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_1_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: packet_size
    type: byte
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_tag_gate_0_0_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_tag_gate_0_0_0_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_tag_gate_0_0_0_0_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_tag_gate_0_0_0_0_0_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_tag_gate_0_0_0_0_1
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_tag_gate_0_0_0_1
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {}
- name: blocks_tag_gate_0_0_0_1_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: bypassed}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: constel.bits_per_symbol()
  states: {}
- name: blocks_unpack_k_bits_bb_0_0_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0_0_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0_0_0_1
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0_0_1_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.00125'
    seed: '0'
    taps: '1.0'
  states: {}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: constel
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_constellation_receiver_cb_0
  id: digital_constellation_receiver_cb
  parameters:
    comment: |-
      ATTENTION: Maximum Freq Deviation
       ADC/DAC Sample Rate Mismatch Worst-Case PPM (100PPM*2 Usual)
       5Hz Minimum Tolerance
       TX/RX Oscillator Mismatch Worst-Case PPM (100PPM*2 Usual)
    constellation: constel
    fmax: int((samp_rate*(200/1000000))+5+((samp_rate*shift_factor)*(200/1000000)))
    fmin: (1/modulus)*(0.02/math.sqrt(modulus))
    loop_bw: (2*3.14)/100
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: access_key
    tagname: packet_len
    threshold: '0'
    type: byte
  states: {}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: modulus
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: constel.pre_diff_code()
  states: {}
- name: digital_map_bb_0_0_0_0
  id: digital_map_bb
  parameters:
    map: '[-1, 1]'
  states: {}
- name: digital_map_bb_0_0_0_0_0
  id: digital_map_bb
  parameters:
    map: '[-1, 1]'
  states: {state: disabled}
- name: digital_pfb_clock_sync_xxx_0_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    comment: |-
      ATTENTION: Loop Bandwidth
      ATTENTION: Maximum Rate Deviation
    filter_size: nfilts
    init_phase: (((nfilts/2)*1)*1)+0
    loop_bw: ((math.sqrt(modulus)*3.14)/100)
    max_dev: ((1/modulus)*16)
    osps: '1'
    sps: sps
    taps: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, int(11*sps*nfilts))
    type: ccf
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format
    len_tag_key: '"packet_len"'
  states: {}
- name: fec_extended_decoder_0_1_0
  id: fec_extended_decoder
  parameters:
    decoder_list: variable_cc_decoder_def_0
    puncpat: '11'
    threadtype: capillary
  states: {}
- name: fec_extended_decoder_0_1_0_0
  id: fec_extended_decoder
  parameters:
    decoder_list: variable_cc_decoder_def_0
    puncpat: '11'
    threadtype: capillary
  states: {state: disabled}
- name: fec_extended_encoder_1_0_0
  id: fec_extended_encoder
  parameters:
    encoder_list: variable_cc_encoder_def_0
    puncpat: '11'
    threadtype: capillary
  states: {}
- name: fec_extended_encoder_1_0_0_0
  id: fec_extended_encoder
  parameters:
    encoder_list: variable_cc_encoder_def_0
    puncpat: '11'
    threadtype: capillary
  states: {state: disabled}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: (-1)*((samp_rate*shift_factor)*(1/sps)*(1/interpolation))
    comment: firdes.low_pass(1,samp_rate,samp_rate/(2*decimation), transitionHertz)
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.complex_band_pass(1, samp_rate, -samp_rate/(2*(1.0*(4/4))), samp_rate/(2*(1.0*(4/4))), samp_rate/4)
  states: {}
- name: freq_xlating_fft_filter_ccc_0_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: (1)*((samp_rate*shift_factor)*(1/sps)*(1/interpolation))
    comment: firdes.low_pass(1,samp_rate,samp_rate/(2*decimation), transitionHertz)
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.complex_band_pass(1, samp_rate, -samp_rate/(2*(1.0*(4/4))), samp_rate/(2*(1.0*(4/4))), samp_rate/4)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import os
  states: {}
- name: import_cmath
  id: import
  parameters:
    imports: import cmath
  states: {}
- name: import_math
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    comment: Modem
    grid: 'True'
    gui_hint: qtgui_tab_widget_0@0
    size: '8192'
    type: complex
    xmax: '1.25'
    xmin: '-1.25'
    ymax: '1.25'
    ymin: '-1.25'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    comment: TX
    fc: '0'
    fftsize: '1024'
    gui_hint: qtgui_tab_widget_0@4
    type: complex
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    comment: Clock
    fc: '0'
    fftsize: '1024'
    gui_hint: qtgui_tab_widget_0@2
    type: complex
  states: {}
- name: qtgui_sink_x_0_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    comment: Analog
    fc: '0'
    fftsize: '1024'
    gui_hint: qtgui_tab_widget_0@1
    type: complex
  states: {}
- name: qtgui_sink_x_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    comment: File
    fc: '0'
    fftsize: '1024'
    gui_hint: qtgui_tab_widget_0@3
    type: complex
  states: {}
- name: qtgui_tab_widget_0
  id: qtgui_tab_widget
  parameters:
    label0: Modem
    label1: Analog
    label2: Clock
    label3: File
    label4: TX
    num_tabs: '5'
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_pfb_clock_sync_xxx_0_0, '0']
- [analog_pwr_squelch_xx_0, '0', freq_xlating_fft_filter_ccc_0_0, '0']
- [audio_source_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [audio_source_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_char_to_float_0, '0', blocks_float_to_complex_1, '0']
- [blocks_char_to_float_0_2_0, '0', fec_extended_decoder_0_1_0, '0']
- [blocks_char_to_float_0_2_0_0, '0', fec_extended_decoder_0_1_0_0, '0']
- [blocks_complex_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_float_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_file_source_0_0_0, '0', blocks_unpack_k_bits_bb_0_0_0_1, '0']
- [blocks_float_to_complex_0, '0', channels_channel_model_0, '0']
- [blocks_float_to_complex_1, '0', qtgui_sink_x_1, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_float_to_complex_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_float_to_complex_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_char_to_float_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_tag_gate_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_unpack_k_bits_bb_0_0_0_0_0, '0']
- [blocks_pack_k_bits_bb_0_0_0_0, '0', blocks_file_sink_0_0_0, '0']
- [blocks_pack_k_bits_bb_0_0_0_0_0, '0', blocks_tag_gate_0, '0']
- [blocks_pack_k_bits_bb_0_0_0_1, '0', blocks_tag_gate_0_0_0_0_1, '0']
- [blocks_pack_k_bits_bb_1_0, '0', digital_constellation_modulator_0_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '1']
- [blocks_stream_to_tagged_stream_0, '0', digital_protocol_formatter_bb_0, '0']
- [blocks_tag_gate_0, '0', blocks_tag_gate_0_0_0_0_0, '0']
- [blocks_tag_gate_0_0_0, '0', blocks_unpack_k_bits_bb_0_0_0_1_0, '0']
- [blocks_tag_gate_0_0_0, '0', digital_constellation_modulator_0_0, '0']
- [blocks_tag_gate_0_0_0_0, '0', blocks_tag_gate_0_0_0, '0']
- [blocks_tag_gate_0_0_0_0_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_tag_gate_0_0_0_0_0_0, '0', blocks_unpack_k_bits_bb_0_0_0_0, '0']
- [blocks_tag_gate_0_0_0_0_1, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_tag_gate_0_0_0_1, '0', freq_xlating_fft_filter_ccc_0, '0']
- [blocks_tag_gate_0_0_0_1_0, '0', analog_agc_xx_0, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_tag_gate_0_0_0_0, '0']
- [blocks_throttle_0, '0', blocks_tag_gate_0_0_0_1, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_unpack_k_bits_bb_0_0_0_0, '0', digital_map_bb_0_0_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0_0_0_0, '0', digital_map_bb_0_0_0_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0_0_1, '0', fec_extended_encoder_1_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0_0_1_0, '0', fec_extended_encoder_1_0_0_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_tag_gate_0_0_0_0_0_0, '0']
- [channels_channel_model_0, '0', analog_pwr_squelch_xx_0, '0']
- [channels_channel_model_0, '0', qtgui_sink_x_0_1, '0']
- [digital_constellation_modulator_0_0, '0', blocks_throttle_0, '0']
- [digital_constellation_receiver_cb_0, '0', blocks_null_sink_0, '0']
- [digital_constellation_receiver_cb_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_constellation_receiver_cb_0, '1', blocks_null_sink_1, '0']
- [digital_constellation_receiver_cb_0, '2', blocks_null_sink_1_0, '0']
- [digital_constellation_receiver_cb_0, '3', blocks_null_sink_1_1, '0']
- [digital_constellation_receiver_cb_0, '4', qtgui_const_sink_x_0_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [digital_diff_decoder_bb_0_0, '0', digital_map_bb_0, '0']
- [digital_map_bb_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [digital_map_bb_0_0_0_0, '0', blocks_char_to_float_0_2_0, '0']
- [digital_map_bb_0_0_0_0_0, '0', blocks_char_to_float_0_2_0_0, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', digital_constellation_receiver_cb_0, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', qtgui_sink_x_0_0, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '0']
- [fec_extended_decoder_0_1_0, '0', blocks_pack_k_bits_bb_0_0_0_0, '0']
- [fec_extended_decoder_0_1_0_0, '0', blocks_pack_k_bits_bb_0_0_0_0_0, '0']
- [fec_extended_encoder_1_0_0, '0', blocks_pack_k_bits_bb_0_0_0_1, '0']
- [fec_extended_encoder_1_0_0_0, '0', blocks_pack_k_bits_bb_1_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', blocks_complex_to_float_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', qtgui_sink_x_0, '0']
- [freq_xlating_fft_filter_ccc_0_0, '0', blocks_tag_gate_0_0_0_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
