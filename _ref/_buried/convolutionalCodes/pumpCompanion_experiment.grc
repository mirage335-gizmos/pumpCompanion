options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: pumpCompanion_experiment
    output_language: python
  states: {}

blocks:
- name: blocks_char_to_float_0_2_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_2_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: os.path.join(os.environ['HOME'], 'Downloads', '_diag.rrf') if os.name == 'posix' else  os.path.join(os.environ['USERPROFILE'], 'Downloads', '_diag.rrf')
    type: byte
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: os.path.join(os.environ['HOME'], 'Downloads', '_framed.rrf') if os.name == 'posix' else  os.path.join(os.environ['USERPROFILE'], 'Downloads', '_framed.rrf')
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_pack_k_bits_bb_0_0_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_0_0_1
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '8'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_packed_to_unpacked_xx_0_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '2'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_tag_gate_0_0_0_0_0_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {state: disabled}
- name: blocks_tag_gate_0_0_0_0_1
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0_0_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0_0_0_1
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '8'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_0_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '2'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '2'
    in_type: byte
    out_type: float
    symbol_table: '[1, 0, 0, 1, 0, -1, -1, 0]'
  states: {}
- name: digital_map_bb_0_0_0_0
  id: digital_map_bb
  parameters:
    map: '[1, 0, 0, 1, 0, -1, -1, 0]'
  states: {state: disabled}
- name: digital_map_bb_0_0_0_0_0
  id: digital_map_bb
  parameters:
    map: '[1, 0, 0, 1, 0, -1, -1, 0]'
  states: {state: bypassed}
- name: digital_map_bb_0_0_0_0_0_0
  id: digital_map_bb
  parameters:
    map: '[1, 0, 0, 1, 0, -1, -1, 0]'
  states: {state: bypassed}
- name: import_0
  id: import
  parameters:
    imports: import os
  states: {}
- name: trellis_encoder_xx_0
  id: trellis_encoder_xx
  parameters:
    fsm_args: '"/usr/share/gnuradio/examples/trellis/fsm_files/awgn1o2_4.fsm"'
    init_state: '0'
    type: bb
  states: {}
- name: trellis_viterbi_combined_xx_0
  id: trellis_viterbi_combined_xx
  parameters:
    block_size: '512'
    dim: '2'
    final_state: '-1'
    fsm_args: '"/usr/share/gnuradio/examples/trellis/fsm_files/awgn1o2_4.fsm"'
    init_state: '0'
    metric_type: digital.TRELLIS_EUCLIDEAN
    out_type: b
    table: '[1, 0, 0, 1, 0, -1, -1, 0]'
    type: f
  states: {}

connections:
- [blocks_char_to_float_0_2_0_0, '0', trellis_viterbi_combined_xx_0, '0']
- [blocks_file_source_0_0_0, '0', blocks_unpack_k_bits_bb_0_0_0_1, '0']
- [blocks_float_to_char_0, '0', digital_map_bb_0_0_0_0_0, '0']
- [blocks_pack_k_bits_bb_0_0_0_0, '0', blocks_file_sink_0_0_0, '0']
- [blocks_pack_k_bits_bb_0_0_0_1, '0', blocks_tag_gate_0_0_0_0_1, '0']
- [blocks_packed_to_unpacked_xx_0, '0', blocks_char_to_float_0_2_0_0, '0']
- [blocks_packed_to_unpacked_xx_0_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_tag_gate_0_0_0_0_0_0, '0', blocks_unpack_k_bits_bb_0_0_0_0, '0']
- [blocks_tag_gate_0_0_0_0_1, '0', blocks_tag_gate_0_0_0_0_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0_0_0, '0', digital_map_bb_0_0_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0_0_1, '0', trellis_encoder_xx_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_unpacked_to_packed_xx_0_0, '0', blocks_packed_to_unpacked_xx_0_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_float_to_char_0, '0']
- [digital_map_bb_0_0_0_0, '0', blocks_char_to_float_0_2_0, '0']
- [digital_map_bb_0_0_0_0_0, '0', digital_map_bb_0_0_0_0_0_0, '0']
- [digital_map_bb_0_0_0_0_0_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [trellis_encoder_xx_0, '0', blocks_pack_k_bits_bb_0_0_0_1, '0']
- [trellis_encoder_xx_0, '0', blocks_unpacked_to_packed_xx_0_0, '0']
- [trellis_viterbi_combined_xx_0, '0', blocks_pack_k_bits_bb_0_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
