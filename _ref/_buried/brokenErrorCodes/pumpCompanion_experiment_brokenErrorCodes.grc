options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: pumpCompanion_experiment
    output_language: python
  states: {}

blocks:
- name: G
  id: variable_ldpc_G_matrix_def
  parameters:
    filename: gr.prefix() + "/share/gnuradio/fec/ldpc/" + "n_0100_k_0058_gen_matrix.alist"
  states: {state: disabled}
- name: H
  id: variable_ldpc_H_matrix_def
  parameters:
    filename: /usr/share/gnuradio/fec/ldpc/n_0100_k_0023_gap_10.alist
    gap: '10'
  states: {}
- name: block_size
  id: variable
  parameters:
    comment: |-
      codeword size of polar codes.

      MUST be a power of 2!
      MUST be greater than 'frame_size'.
    value: '512'
  states: {}
- name: dec_cc
  id: variable_cc_decoder_def
  parameters:
    framebits: frame_size*8
    k: k
    mode: fec.CC_TAILBITING
    ndim: '0'
    padding: 'False'
    polys: polys
    rate: rate
    state_end: '-1'
    state_start: '0'
  states: {}
- name: dec_rep
  id: variable_repetition_decoder_def
  parameters:
    framebits: frame_size*8
    ndim: '0'
    prob: '0.5'
    rep: '3'
  states: {state: disabled}
- name: enc_ccsds
  id: variable_ccsds_encoder_def
  parameters:
    framebits: frame_size*8
    mode: fec.CC_TAILBITING
    ndim: '0'
    state_start: '0'
  states: {}
- name: enc_rep
  id: variable_repetition_encoder_def
  parameters:
    framebits: frame_size*8
    ndim: '0'
    rep: '3'
  states: {state: disabled}
- name: k
  id: variable
  parameters:
    value: '7'
  states: {}
- name: ldpc_dec
  id: variable_ldpc_decoder_def
  parameters:
    file: /usr/share/gnuradio/fec/ldpc/n_0500_k_0127_gap_21.alist
    max_iter: '100'
    ndim: '0'
    sigma: '0.5'
  states: {}
- name: ldpc_dec_G
  id: variable_ldpc_bit_flip_decoder_def
  parameters:
    matrix_object: G
    max_iterations: '100'
    ndim: '0'
  states: {state: disabled}
- name: ldpc_dec_H
  id: variable_ldpc_bit_flip_decoder_def
  parameters:
    matrix_object: H
    max_iterations: '5'
    ndim: '0'
  states: {}
- name: ldpc_enc
  id: variable_ldpc_encoder_def
  parameters:
    file: /usr/share/gnuradio/fec/ldpc/n_0100_k_0023_gap_10.alist
    ndim: '0'
  states: {}
- name: ldpc_enc_G
  id: variable_ldpc_encoder_G_def
  parameters:
    G: G
    ndim: '0'
  states: {state: disabled}
- name: ldpc_enc_H
  id: variable_ldpc_encoder_H_def
  parameters:
    H: H
    ndim: '0'
  states: {}
- name: polar_config
  id: variable_polar_code_configurator
  parameters:
    block_size: block_size
    channel: polar.CHANNEL_TYPE_BEC
    comment: |-
      Block is used to configure polar encoders and decoders.

      returns dictionary with requested configuration.

      most important dict values: 'values' and 'positions'
    design_snr: '0.0'
    mu: '32'
    num_info_bits: frame_size * 8
  states: {}
- name: polar_decoder_sc
  id: variable_polar_decoder_sc_def
  parameters:
    block_size: block_size
    comment: |-
      Standard 'Successive Cancellation' decoder.

      performs better with greater block size.
      This is due to stronger polarization at higher block sizes.
    frozen_bit_positions: polar_config['positions']
    frozen_bit_values: polar_config['values']
    ndim: '0'
    num_info_bits: frame_size * 8
  states: {}
- name: polar_decoder_scl
  id: variable_polar_decoder_sc_list_def
  parameters:
    block_size: block_size
    comment: |-
      Advanced 'Successive Cancellation List' decoder

      Greater list size usually results in better decoding performance.
      But it is computationally more heavy.
    frozen_bit_positions: polar_config['positions']
    frozen_bit_values: polar_config['values']
    max_list_size: '8'
    ndim: '0'
    num_info_bits: frame_size * 8
  states: {}
- name: polar_encoder_sc
  id: variable_polar_encoder_def
  parameters:
    block_size: block_size
    frozen_bit_positions: polar_config['positions']
    frozen_bit_values: polar_config['values']
    is_packed: 'False'
    ndim: '0'
    num_info_bits: frame_size * 8
  states: {}
- name: polar_encoder_scl
  id: variable_polar_encoder_def
  parameters:
    block_size: block_size
    frozen_bit_positions: polar_config['positions']
    frozen_bit_values: polar_config['values']
    is_packed: 'False'
    ndim: '0'
    num_info_bits: frame_size * 8
  states: {}
- name: polys
  id: variable
  parameters:
    value: '[109, 79]'
  states: {}
- name: rate
  id: variable
  parameters:
    value: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: blocks_char_to_float_0_2
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '0'
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/user/Downloads/_diag.rrf
    type: byte
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/user/Downloads/_framed.rrf
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {state: bypassed}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '32'
    type: byte
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '30'
    type: byte
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '1'
    type: byte
    vlen: (8*(239-51))
  states: {state: disabled}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '1'
    type: byte
    vlen: (8*(255-51))
  states: {state: disabled}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {state: disabled}
- name: blocks_tag_gate_0_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {state: bypassed}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '1'
    type: byte
    vlen: (8*(255-51))
  states: {state: disabled}
- name: blocks_vector_to_stream_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '1'
    type: byte
    vlen: (8*(239-51))
  states: {state: disabled}
- name: digital_map_bb_0_0_0
  id: digital_map_bb
  parameters:
    map: '[-1, 1]'
  states: {}
- name: dtv_dvbt_reed_solomon_dec_0
  id: dtv_dvbt_reed_solomon_dec
  parameters:
    blocks: '8'
    gfpoly: '0x11d'
    k: '239'
    m: '8'
    n: '255'
    p: '2'
    s: '51'
    t: '8'
  states: {state: disabled}
- name: dtv_dvbt_reed_solomon_enc_0
  id: dtv_dvbt_reed_solomon_enc
  parameters:
    blocks: '8'
    gfpoly: '0x11d'
    k: '239'
    m: '8'
    n: '255'
    p: '2'
    s: '51'
    t: '8'
  states: {state: disabled}
- name: fec_depuncture_bb_0
  id: fec_depuncture_bb
  parameters:
    delay: '0'
    puncpat: '0xFEFFFFF'
    puncsize: '28'
  states: {state: disabled}
- name: fec_depuncture_bb_0_0
  id: fec_depuncture_bb
  parameters:
    delay: '0'
    puncpat: '0xFEFF'
    puncsize: '16'
  states: {}
- name: fec_extended_decoder_0
  id: fec_extended_decoder
  parameters:
    decoder_list: ldpc_dec_H
    puncpat: puncpat
    threadtype: ordinary
  states: {}
- name: fec_extended_decoder_0_0
  id: fec_extended_decoder
  parameters:
    decoder_list: dec_cc
    puncpat: puncpat
    threadtype: none
  states: {state: disabled}
- name: fec_extended_decoder_0_1
  id: fec_extended_decoder
  parameters:
    decoder_list: dec_rep
    puncpat: puncpat
    threadtype: none
  states: {state: disabled}
- name: fec_extended_decoder_0_1_0
  id: fec_extended_decoder
  parameters:
    decoder_list: polar_decoder_sc
    puncpat: puncpat
    threadtype: none
  states: {state: disabled}
- name: fec_extended_encoder_1
  id: fec_extended_encoder
  parameters:
    encoder_list: ldpc_enc_H
    puncpat: puncpat
    threadtype: ordinary
  states: {}
- name: fec_extended_encoder_1_0
  id: fec_extended_encoder
  parameters:
    encoder_list: enc_rep
    puncpat: puncpat
    threadtype: capillary
  states: {state: disabled}
- name: fec_extended_encoder_1_0_0
  id: fec_extended_encoder
  parameters:
    encoder_list: polar_encoder_sc
    puncpat: puncpat
    threadtype: capillary
  states: {state: disabled}
- name: fec_extended_encoder_1_1
  id: fec_extended_encoder
  parameters:
    encoder_list: enc_ccsds
    puncpat: puncpat
    threadtype: capillary
  states: {state: disabled}
- name: fec_puncture_xx_0
  id: fec_puncture_xx
  parameters:
    delay: '0'
    puncpat: '0xFEFFFFF'
    puncsize: '28'
    type: byte
  states: {state: disabled}
- name: fec_puncture_xx_0_0
  id: fec_puncture_xx
  parameters:
    delay: '0'
    puncpat: '0xFEFF'
    puncsize: '16'
    type: byte
  states: {}
- name: frame_size
  id: parameter
  parameters:
    label: Frame Size
    type: intx
    value: '30'
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: pdu_tagged_stream_to_pdu_0_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: puncpat
  id: parameter
  parameters:
    value: '''11'''
  states: {}
- name: satellites_decode_rs_0
  id: satellites_decode_rs
  parameters:
    fcr: '1'
    gfpoly: '285'
    interleave: '1'
    nroots: '1'
    nsym: '8'
    prim: '1'
  states: {state: disabled}
- name: satellites_encode_rs_0
  id: satellites_encode_rs
  parameters:
    fcr: '1'
    gfpoly: '285'
    interleave: '1'
    nroots: '1'
    nsym: '8'
    prim: '1'
  states: {state: disabled}

connections:
- [blocks_char_to_float_0_2, '0', fec_extended_decoder_0, '0']
- [blocks_char_to_float_0_2, '0', fec_extended_decoder_0_0, '0']
- [blocks_char_to_float_0_2, '0', fec_extended_decoder_0_1, '0']
- [blocks_char_to_float_0_2, '0', fec_extended_decoder_0_1_0, '0']
- [blocks_delay_0, '0', fec_depuncture_bb_0, '0']
- [blocks_file_source_0_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_file_source_0_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [blocks_pack_k_bits_bb_0, '0', digital_map_bb_0_0_0, '0']
- [blocks_pack_k_bits_bb_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', pdu_tagged_stream_to_pdu_0_0, '0']
- [blocks_stream_to_vector_0, '0', dtv_dvbt_reed_solomon_enc_0, '0']
- [blocks_stream_to_vector_0_0, '0', dtv_dvbt_reed_solomon_dec_0, '0']
- [blocks_tag_gate_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_tag_gate_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', fec_puncture_xx_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', fec_puncture_xx_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', fec_extended_encoder_1, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', fec_extended_encoder_1_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', fec_extended_encoder_1_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', fec_extended_encoder_1_1, '0']
- [digital_map_bb_0_0_0, '0', blocks_char_to_float_0_2, '0']
- [dtv_dvbt_reed_solomon_dec_0, '0', blocks_vector_to_stream_0_0_0, '0']
- [dtv_dvbt_reed_solomon_enc_0, '0', blocks_vector_to_stream_0_0, '0']
- [fec_depuncture_bb_0, '0', blocks_pack_k_bits_bb_0, '0']
- [fec_depuncture_bb_0_0, '0', blocks_pack_k_bits_bb_0, '0']
- [fec_extended_decoder_0, '0', blocks_pack_k_bits_bb_0_0, '0']
- [fec_extended_decoder_0_0, '0', blocks_pack_k_bits_bb_0_0, '0']
- [fec_extended_decoder_0_1, '0', blocks_pack_k_bits_bb_0_0, '0']
- [fec_extended_decoder_0_1_0, '0', blocks_pack_k_bits_bb_0_0, '0']
- [fec_extended_encoder_1, '0', blocks_unpack_k_bits_bb_0, '0']
- [fec_extended_encoder_1_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [fec_extended_encoder_1_0_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [fec_extended_encoder_1_1, '0', blocks_unpack_k_bits_bb_0, '0']
- [fec_puncture_xx_0, '0', blocks_delay_0, '0']
- [fec_puncture_xx_0_0, '0', fec_depuncture_bb_0_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_tag_gate_0, '0']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_tag_gate_0_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, satellites_encode_rs_0, in]
- [pdu_tagged_stream_to_pdu_0_0, pdus, satellites_decode_rs_0, in]
- [satellites_decode_rs_0, out, pdu_pdu_to_tagged_stream_0_0, pdus]
- [satellites_encode_rs_0, out, pdu_pdu_to_tagged_stream_0, pdus]

metadata:
  file_format: 1
  grc_version: 3.10.5.1
