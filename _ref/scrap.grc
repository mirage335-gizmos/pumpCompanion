options:
  parameters:
    author: user
    generate_options: qt_gui
    id: scrap
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: H
  id: variable_ldpc_H_matrix_def
  parameters:
    filename: /usr/share/gnuradio/fec/ldpc/n_0100_k_0023_gap_10.alist
    gap: '10'
  states: {state: disabled}
- name: H
  id: variable_ldpc_H_matrix_def
  parameters:
    comment: Packet length must match   n bytes .
    filename: /usr/share/gnuradio/fec/ldpc/n_0500_k_0127_gap_21.alist
    gap: '21'
  states: {}
- name: access_key
  id: variable
  parameters:
    comment: |-
      Default:
      '1110 0001 0101 1010 1110 1000 1001 0011'
      '11100001010110101110100010010011'
      Alt:
      '1111 1111 1111 1111 1111 0000 0000 0011'
      '11111111111111111111000000000011'
      Unusual:   1 0000 1   1 1111 1   0011 11
    value: '''11111111111111111111000000000011'''
  states: {}
- name: arity
  id: variable
  parameters:
    value: modulus
  states: {}
- name: constel
  id: variable_constellation
  parameters:
    comment: QAM256
    const_points: '[(-15-15j),(-13-15j),(-11-15j),(-9-15j),(-7-15j),(-5-15j),(-3-15j),(-1-15j),(1-15j),(3-15j),(5-15j),(7-15j),(9-15j),(11-15j),(13-15j),(15-15j),(-15-13j),(-13-13j),(-11-13j),(-9-13j),(-7-13j),(-5-13j),(-3-13j),(-1-13j),(1-13j),(3-13j),(5-13j),(7-13j),(9-13j),(11-13j),(13-13j),(15-13j),(-15-11j),(-13-11j),(-11-11j),(-9-11j),(-7-11j),(-5-11j),(-3-11j),(-1-11j),(1-11j),(3-11j),(5-11j),(7-11j),(9-11j),(11-11j),(13-11j),(15-11j),(-15-9j),(-13-9j),(-11-9j),(-9-9j),(-7-9j),(-5-9j),(-3-9j),(-1-9j),(1-9j),(3-9j),(5-9j),(7-9j),(9-9j),(11-9j),(13-9j),(15-9j),(-15-7j),(-13-7j),(-11-7j),(-9-7j),(-7-7j),(-5-7j),(-3-7j),(-1-7j),(1-7j),(3-7j),(5-7j),(7-7j),(9-7j),(11-7j),(13-7j),(15-7j),(-15-5j),(-13-5j),(-11-5j),(-9-5j),(-7-5j),(-5-5j),(-3-5j),(-1-5j),(1-5j),(3-5j),(5-5j),(7-5j),(9-5j),(11-5j),(13-5j),(15-5j),(-15-3j),(-13-3j),(-11-3j),(-9-3j),(-7-3j),(-5-3j),(-3-3j),(-1-3j),(1-3j),(3-3j),(5-3j),(7-3j),(9-3j),(11-3j),(13-3j),(15-3j),(-15-1j),(-13-1j),(-11-1j),(-9-1j),(-7-1j),(-5-1j),(-3-1j),(-1-1j),(1-1j),(3-1j),(5-1j),(7-1j),(9-1j),(11-1j),(13-1j),(15-1j),(-15+1j),(-13+1j),(-11+1j),(-9+1j),(-7+1j),(-5+1j),(-3+1j),(-1+1j),(1+1j),(3+1j),(5+1j),(7+1j),(9+1j),(11+1j),(13+1j),(15+1j),(-15+3j),(-13+3j),(-11+3j),(-9+3j),(-7+3j),(-5+3j),(-3+3j),(-1+3j),(1+3j),(3+3j),(5+3j),(7+3j),(9+3j),(11+3j),(13+3j),(15+3j),(-15+5j),(-13+5j),(-11+5j),(-9+5j),(-7+5j),(-5+5j),(-3+5j),(-1+5j),(1+5j),(3+5j),(5+5j),(7+5j),(9+5j),(11+5j),(13+5j),(15+5j),(-15+7j),(-13+7j),(-11+7j),(-9+7j),(-7+7j),(-5+7j),(-3+7j),(-1+7j),(1+7j),(3+7j),(5+7j),(7+7j),(9+7j),(11+7j),(13+7j),(15+7j),(-15+9j),(-13+9j),(-11+9j),(-9+9j),(-7+9j),(-5+9j),(-3+9j),(-1+9j),(1+9j),(3+9j),(5+9j),(7+9j),(9+9j),(11+9j),(13+9j),(15+9j),(-15+11j),(-13+11j),(-11+11j),(-9+11j),(-7+11j),(-5+11j),(-3+11j),(-1+11j),(1+11j),(3+11j),(5+11j),(7+11j),(9+11j),(11+11j),(13+11j),(15+11j),(-15+13j),(-13+13j),(-11+13j),(-9+13j),(-7+13j),(-5+13j),(-3+13j),(-1+13j),(1+13j),(3+13j),(5+13j),(7+13j),(9+13j),(11+13j),(13+13j),(15+13j),(-15+15j),(-13+15j),(-11+15j),(-9+15j),(-7+15j),(-5+15j),(-3+15j),(-1+15j),(1+15j),(3+15j),(5+15j),(7+15j),(9+15j),(11+15j),(13+15j),(15+15j)]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 4, 12, 8, 1, 5, 13, 9, 3, 7, 15, 11, 2, 6, 14, 10, 16, 20, 28, 24, 17, 21, 29, 25, 19, 23, 31, 27, 18, 22, 30, 26, 32, 36, 44, 40, 33, 37, 45, 41, 35, 39, 47, 43, 34, 38, 46, 42, 48, 52, 60, 56, 49, 53, 61, 57, 51, 55, 63, 59, 50, 54, 62, 58, 64, 68, 76, 72, 65, 69, 77, 73, 67, 71, 79, 75, 66, 70, 78, 74, 80, 84, 92, 88, 81, 85, 93, 89, 83, 87, 95, 91, 82, 86, 94, 90, 96, 100, 108, 104, 97, 101, 109, 105, 99, 103, 111, 107, 98, 102, 110, 106, 112, 116, 124, 120, 113, 117, 125, 121, 115, 119, 127, 123, 114, 118, 126, 122, 128, 132, 140, 136, 129, 133, 141, 137, 131, 135, 143, 139, 130, 134, 142, 138, 144, 148, 156, 152, 145, 149, 157, 153, 147, 151, 159, 155, 146, 150, 158, 154, 160, 164, 172, 168, 161, 165, 173, 169, 163, 167, 175, 171, 162, 166, 174, 170, 176, 180, 188, 184, 177, 181, 189, 185, 179, 183, 191, 187, 178, 182, 190, 186, 192, 196, 204, 200, 193, 197, 205, 201, 195, 199, 207, 203, 194, 198, 206, 202, 208, 212, 220, 216, 209, 213, 221, 217, 211, 215, 223, 219, 210, 214, 222, 218, 224, 228, 236, 232, 225, 229, 237, 233, 227, 231, 239, 235, 226, 230, 238, 234, 240, 244, 252, 248, 241, 245, 253, 249, 243, 247, 255, 251, 242, 246, 254, 250]'
    type: calcdist
  states: {}
- name: constel
  id: variable_constellation
  parameters:
    comment: |-
      QAM64
      sps 6 recommended for nfilts 32
    const_points: '[ (-7-7j),(-5-7j),(-3-7j),(-1-7j),(1-7j),(3-7j),(5-7j),(7-7j),(-7-5j),(-5-5j),(-3-5j),(-1-5j),(1-5j),(3-5j),(5-5j),(7-5j),(-7-3j),(-5-3j),(-3-3j),(-1-3j),(1-3j),(3-3j),(5-3j),(7-3j),(-7-1j),(-5-1j),(-3-1j),(-1-1j),(1-1j),(3-1j),(5-1j),(7-1j),(-7+1j),(-5+1j),(-3+1j),(-1+1j),(1+1j),(3+1j),(5+1j),(7+1j),(-7+3j),(-5+3j),(-3+3j),(-1+3j),(1+3j),(3+3j),(5+3j),(7+3j),(-7+5j),(-5+5j),(-3+5j),(-1+5j),(1+5j),(3+5j),(5+5j),(7+5j),(-7+7j),(-5+7j),(-3+7j),(-1+7j),(1+7j),(3+7j),(5+7j),(7+7j) ]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 4, 12, 8, 1, 5, 13, 9, 3, 7, 15, 11, 2, 6, 14, 10, 16, 20, 28, 24, 17, 21, 29, 25, 19, 23, 31, 27, 18, 22, 30, 26, 32, 36, 44, 40, 33, 37, 45, 41, 35, 39, 47, 43, 34, 38, 46, 42, 48, 52, 60, 56, 49, 53, 61, 57, 51, 55, 63, 59, 50, 54, 62, 58]'
    type: calcdist
  states: {state: disabled}
- name: constel
  id: variable_constellation
  parameters:
    const_points: digital.qam_16()[0]
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    soft_dec_lut: '''auto'''
    sym_map: digital.qam_16()[1]
    type: calcdist
  states: {state: disabled}
- name: constel_0
  id: variable
  parameters:
    value: digital.qam_constellation(constellation_points=16, differential=True, mod_code='none').base()
  states: {}
- name: dec_rep
  id: variable_repetition_decoder_def
  parameters:
    framebits: (packet_size+4)*8
    ndim: '0'
    prob: '0.5'
    rep: repetitions
  states: {}
- name: enc_rep
  id: variable_repetition_encoder_def
  parameters:
    framebits: (packet_size+4)*8
    ndim: '0'
    rep: repetitions
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.275'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: interpolation
  id: variable
  parameters:
    value: '1'
  states: {}
- name: ldpc_dec_H
  id: variable_ldpc_bit_flip_decoder_def
  parameters:
    comment: |-
      Seems more effective than other FEC
      provided with GNURadio.
      Yet, still seems not very effective for FEC.
      Discouraged.
    matrix_object: H
    max_iterations: '5'
    ndim: '0'
  states: {state: disabled}
- name: ldpc_dec_H
  id: variable_ldpc_bit_flip_decoder_def
  parameters:
    comment: |-
      Seems more effective than other FEC
      provided with GNURadio.
      Yet, still seems not very effective for FEC.
      Discouraged.
    matrix_object: H
    max_iterations: '100'
    ndim: '0'
  states: {}
- name: ldpc_enc_H
  id: variable_ldpc_encoder_H_def
  parameters:
    H: H
    ndim: '0'
  states: {state: disabled}
- name: ldpc_enc_H
  id: variable_ldpc_encoder_H_def
  parameters:
    H: H
    ndim: '0'
  states: {}
- name: modulus
  id: variable
  parameters:
    value: pow(2,constel.bits_per_symbol())
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: int(32*(modulus/16))
  states: {}
- name: packet_size
  id: variable
  parameters:
    comment: |-
      CAUTION: Do NOT
      exceed 140 bytes!
      (or >>1/3 of pattern
      after footer)
    value: '500'
  states: {}
- name: repetitions
  id: variable
  parameters:
    value: '3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: shift_factor
  id: variable
  parameters:
    value: ((325/samp_rate)*4)+(0.5)+(excess_bw*0.5)
  states: {}
- name: sps
  id: variable
  parameters:
    comment: samp_sym_rate
    value: '3'
  states: {}
- name: variable_cc_decoder_def_0
  id: variable_cc_decoder_def
  parameters:
    framebits: '2048'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: '[79,109]'
    rate: '2'
    state_end: '-1'
    state_start: '0'
  states: {}
- name: variable_cc_encoder_def_0
  id: variable_cc_encoder_def
  parameters:
    framebits: '2048'
    k: '7'
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: '[79,109]'
    rate: '2'
    state_start: '0'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '255'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '255'
  states: {}
- name: blocks_char_to_float_0_2
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_2_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_2_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_2_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_2_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: os.path.join(os.environ['HOME'], 'Downloads', '_diag.rrf') if os.name == 'posix' else  os.path.join(os.environ['USERPROFILE'], 'Downloads', '_diag.rrf')
    type: byte
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: os.path.join(os.environ['HOME'], 'Downloads', '_framed.rrf') if os.name == 'posix' else  os.path.join(os.environ['USERPROFILE'], 'Downloads', '_framed.rrf')
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0_0_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_0_0_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_0_0_0_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0_0_0_0_1
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_0_0_1
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_0_0_1_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_0_0_1_1
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_1_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_tag_gate_0_0_0_0_0_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_tag_gate_0_0_0_0_0_0_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_tag_gate_0_0_0_0_0_0_1
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_tag_gate_0_0_0_0_1
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_tag_gate_0_0_0_0_1_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_tag_gate_0_0_0_0_1_1
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0_0_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0_0_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0_0_0_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0_0_0_0_1
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0_0_1
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0_0_1_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_0_0_0_1_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0_0_0_1_1
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: digital_map_bb_0_0_0
  id: digital_map_bb
  parameters:
    map: '[-1, 1]'
  states: {state: disabled}
- name: digital_map_bb_0_0_0_0
  id: digital_map_bb
  parameters:
    map: '[-1, 1]'
  states: {}
- name: digital_map_bb_0_0_0_0_0
  id: digital_map_bb
  parameters:
    map: '[-1, 1]'
  states: {}
- name: digital_map_bb_0_0_0_0_0_0
  id: digital_map_bb
  parameters:
    map: '[-1, 1]'
  states: {state: disabled}
- name: digital_map_bb_0_0_0_0_1
  id: digital_map_bb
  parameters:
    map: '[-1, 1]'
  states: {}
- name: fec_ber_bf_0
  id: fec_ber_bf
  parameters:
    berminerrors: berminerrs
    test_mode: 'False'
  states: {}
- name: fec_depuncture_bb_0_0
  id: fec_depuncture_bb
  parameters:
    delay: '0'
    puncpat: '0xFEFF'
    puncsize: '16'
  states: {state: disabled}
- name: fec_extended_decoder_0
  id: fec_extended_decoder
  parameters:
    decoder_list: ldpc_dec_H
    puncpat: '11'
    threadtype: ordinary
  states: {state: disabled}
- name: fec_extended_decoder_0_1_0
  id: fec_extended_decoder
  parameters:
    decoder_list: dec_rep
    puncpat: '11'
    threadtype: ordinary
  states: {}
- name: fec_extended_decoder_0_1_0_0
  id: fec_extended_decoder
  parameters:
    decoder_list: ldpc_dec_H
    puncpat: '11'
    threadtype: capillary
  states: {}
- name: fec_extended_decoder_0_1_0_0_0
  id: fec_extended_decoder
  parameters:
    decoder_list: variable_cc_decoder_def_0
    puncpat: '11'
    threadtype: capillary
  states: {state: disabled}
- name: fec_extended_decoder_0_1_0_1
  id: fec_extended_decoder
  parameters:
    decoder_list: variable_cc_decoder_def_0
    puncpat: '11'
    threadtype: capillary
  states: {}
- name: fec_extended_encoder_1
  id: fec_extended_encoder
  parameters:
    encoder_list: ldpc_enc_H
    puncpat: '11'
    threadtype: ordinary
  states: {state: disabled}
- name: fec_extended_encoder_1_0_0
  id: fec_extended_encoder
  parameters:
    encoder_list: enc_rep
    puncpat: '11'
    threadtype: capillary
  states: {}
- name: fec_extended_encoder_1_0_0_0
  id: fec_extended_encoder
  parameters:
    encoder_list: ldpc_enc_H
    puncpat: '11'
    threadtype: capillary
  states: {}
- name: fec_extended_encoder_1_0_0_0_0
  id: fec_extended_encoder
  parameters:
    encoder_list: variable_cc_encoder_def_0
    puncpat: '11'
    threadtype: capillary
  states: {state: disabled}
- name: fec_extended_encoder_1_0_0_1
  id: fec_extended_encoder
  parameters:
    encoder_list: variable_cc_encoder_def_0
    puncpat: '11'
    threadtype: capillary
  states: {}
- name: fec_puncture_xx_0_0
  id: fec_puncture_xx
  parameters:
    delay: '0'
    puncpat: '0xFEFF'
    puncsize: '16'
    type: byte
  states: {state: disabled}
- name: import_cmath
  id: import
  parameters:
    imports: import cmath
  states: {}
- name: import_math
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    color1: ("blue", "red")
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: BER
    max: '10'
    min: '-10'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_char_to_float_0_2, '0', fec_extended_decoder_0, '0']
- [blocks_char_to_float_0_2_0, '0', fec_extended_decoder_0_1_0, '0']
- [blocks_char_to_float_0_2_0_0, '0', fec_extended_decoder_0_1_0_0, '0']
- [blocks_char_to_float_0_2_0_0_0, '0', fec_extended_decoder_0_1_0_0_0, '0']
- [blocks_char_to_float_0_2_0_1, '0', fec_extended_decoder_0_1_0_1, '0']
- [blocks_file_source_0_0_0, '0', blocks_unpack_k_bits_bb_0_0_0_1_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_pack_k_bits_bb_0_0, '0', fec_ber_bf_0, '0']
- [blocks_pack_k_bits_bb_0_0_0_0_0, '0', blocks_file_sink_0_0_0, '0']
- [blocks_pack_k_bits_bb_0_0_0_1, '0', blocks_tag_gate_0_0_0_0_1, '0']
- [blocks_pack_k_bits_bb_0_0_0_1_0, '0', blocks_tag_gate_0_0_0_0_1_0, '0']
- [blocks_pack_k_bits_bb_0_0_0_1_1, '0', blocks_tag_gate_0_0_0_0_1_1, '0']
- [blocks_tag_gate_0_0_0_0_0_0, '0', blocks_unpack_k_bits_bb_0_0_0_0, '0']
- [blocks_tag_gate_0_0_0_0_0_0_0, '0', blocks_unpack_k_bits_bb_0_0_0_0_0, '0']
- [blocks_tag_gate_0_0_0_0_0_0_1, '0', blocks_unpack_k_bits_bb_0_0_0_0_1, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', blocks_pack_k_bits_bb_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0_0, '0', fec_extended_encoder_1, '0']
- [blocks_unpack_k_bits_bb_0_0_0_0, '0', digital_map_bb_0_0_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0_0_0_0, '0', digital_map_bb_0_0_0_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0_0_0_0_0, '0', digital_map_bb_0_0_0_0_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0_0_0_1, '0', digital_map_bb_0_0_0_0_1, '0']
- [blocks_unpack_k_bits_bb_0_0_0_1, '0', fec_extended_encoder_1_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0_0_1_0, '0', fec_extended_encoder_1_0_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0_0_1_0_0, '0', fec_extended_encoder_1_0_0_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0_0_1_1, '0', fec_extended_encoder_1_0_0_1, '0']
- [digital_map_bb_0_0_0, '0', blocks_char_to_float_0_2, '0']
- [digital_map_bb_0_0_0_0, '0', blocks_char_to_float_0_2_0, '0']
- [digital_map_bb_0_0_0_0_0, '0', blocks_char_to_float_0_2_0_0, '0']
- [digital_map_bb_0_0_0_0_0_0, '0', blocks_char_to_float_0_2_0_0_0, '0']
- [digital_map_bb_0_0_0_0_1, '0', blocks_char_to_float_0_2_0_1, '0']
- [fec_ber_bf_0, '0', qtgui_number_sink_0, '0']
- [fec_depuncture_bb_0_0, '0', digital_map_bb_0_0_0, '0']
- [fec_extended_decoder_0, '0', blocks_pack_k_bits_bb_0_0_0, '0']
- [fec_extended_decoder_0_1_0, '0', blocks_pack_k_bits_bb_0_0_0_0, '0']
- [fec_extended_decoder_0_1_0_0, '0', blocks_pack_k_bits_bb_0_0_0_0_0, '0']
- [fec_extended_decoder_0_1_0_0_0, '0', blocks_pack_k_bits_bb_0_0_0_0_0_0, '0']
- [fec_extended_decoder_0_1_0_1, '0', blocks_pack_k_bits_bb_0_0_0_0_1, '0']
- [fec_extended_encoder_1, '0', fec_puncture_xx_0_0, '0']
- [fec_extended_encoder_1_0_0, '0', blocks_pack_k_bits_bb_0_0_0_1, '0']
- [fec_extended_encoder_1_0_0_0, '0', blocks_pack_k_bits_bb_0_0_0_1_0, '0']
- [fec_extended_encoder_1_0_0_0_0, '0', blocks_pack_k_bits_bb_1_0, '0']
- [fec_extended_encoder_1_0_0_1, '0', blocks_pack_k_bits_bb_0_0_0_1_1, '0']
- [fec_puncture_xx_0_0, '0', fec_depuncture_bb_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
